options:
  parameters:
    description: Simple SDR test with signals used in simulation.
    generate_options: qt_gui
    id: SDRtest
    output_language: python
    title: simpleSRDtest
  states: {}

blocks:
- name: LPF
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: NGsource
  id: variable_qtgui_chooser
  parameters:
    label: LimeNG source
    label0: XTRX
    label1: USB
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: RXcarrier_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: RX frequency [MHz]
    start: '100'
    step: '1'
    stop: '1000'
    value: '800.0'
  states: {}
- name: RXgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Rx Gain [dB]
    min_len: '70'
    rangeType: int
    start: '0'
    step: '1'
    stop: '52'
    value: '10'
  states: {}
- name: TXcarrier_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: TX frequency [MHz]
    start: '100'
    step: '1'
    stop: '1000'
    value: '800.0'
    widget: eng
  states: {}
- name: TXgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: TX Gain [dB]
    min_len: '70'
    rangeType: int
    start: '-12'
    step: '1'
    stop: '64'
    value: '10'
  states: {}
- name: bbIamp
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Re baseband amp.
    type: real
    value: '0.5'
  states: {}
- name: bbIfreq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Re baseband frequency [MHz]
    start: '0'
    step: '0.1'
    stop: samp_rate/1e6
    value: '0'
    widget: counter
  states: {}
- name: bbQamp
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,1
    label: Im baseband amp.
    type: real
    value: '0.5'
  states: {}
- name: bbQfreq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Re baseband frequency offset  [Hz]
    start: '0'
    step: '0.020'
    stop: '1000'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: bbIamp
    freq: bbIfreq*1e6
    offset: '-bbIamp/2'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: bbQamp
    freq: (bbIfreq)*1e6+bbQfreq
    offset: '-bbIamp/2'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: NGsource
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: limesuiteng_sdrdevice_sink_0_0
  id: limesuiteng_sdrdevice_sink
  parameters:
    antenna: auto
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: LimeSDR-USB
    gain_generic: TXgain
    lpf: 5e6
    nco_offset: '0'
    rf_freq: TXcarrier_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: '''LNAW'''
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: LimeSDR XTRX
    gain_generic: RXgain
    lpf: LPF
    nco_offset: '0.0'
    rf_freq: RXcarrier_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: limesuiteng_sdrdevice_source_0_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: '''LNAW'''
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: LimeSDR-USB
    gain_generic: RXgain
    lpf: LPF
    nco_offset: '0.0'
    rf_freq: RXcarrier_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: TXcarrier_freq*1e6
    fftsize: '1024'
    gui_hint: 4,0,2,2
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: RXcarrier_freq*1e6
    fftsize: '1024'
    gui_hint: 4,2,2,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,0,2,2
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    gui_hint: 2,2,2,2
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_float_to_complex_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_1, '1']
- [blocks_float_to_complex_1, '0', limesuiteng_sdrdevice_sink_0_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_0_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', blocks_selector_0, '0']
- [limesuiteng_sdrdevice_source_0_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
