options:
  parameters:
    author: RS
    description: Test NG XTRX sink with XTRX source.
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: NG-XTRX sink_test
  states: {}

blocks:
- name: LPF
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Analog filter bandwidth [MHz]
    type: real
    value: samp_rate
  states: {}
- name: RXgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Rx Gain [dB]
    min_len: '70'
    rangeType: int
    start: '0'
    step: '1'
    stop: '52'
    value: '6'
  states: {}
- name: TXgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: TX Gain [dB]
    min_len: '70'
    rangeType: int
    start: '-12'
    step: '1'
    stop: '64'
    value: '10'
  states: {}
- name: baseband
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Baseband [MHz]
    type: real
    value: '800'
  states: {}
- name: digital_filter
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Digital filter bandwidth [MHz]
    type: real
    value: samp_rate/1e6 - 0.3
  states: {}
- name: input_filename
  id: variable
  parameters:
    value: '"NA_50MHz_50Msps_3x10s_250403_1753_int16.iq"'
  states: {}
- name: lna_path
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: LNA Path
    label0: LNAW
    label1: LNAH
    label2: LNAL
    num_opts: '3'
    option0: LNAW
    option1: LNAH
    option2: LNAL
    type: string
    value: LNAW
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to users home directory
    value: '"/datadisk/data/signals/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: test_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: test amplitude
    min_len: '70'
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: test_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: test frequency [KHz]
    min_len: '70'
    start: '0'
    step: '1.0'
    stop: '1000'
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: test_amp
    freq: test_freq*1e3
    offset: test_amp*(1+1j)
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: limesuiteng_sdrdevice_sink_0
  id: limesuiteng_sdrdevice_sink
  parameters:
    antenna: auto
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: LimeSDR XTRX
    gain_generic: TXgain
    lpf: LPF
    nco_offset: '0'
    rf_freq: baseband*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: '''LNAW'''
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: LimeSDR XTRX
    gain_generic: RXgain
    lpf: LPF
    nco_offset: '0.0'
    rf_freq: baseband*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 6,0,1,2
    name: '"XTRX"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 3,0,1,2
    name: '"XTRX"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"test signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', limesuiteng_sdrdevice_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_2, '0']
- [limesuiteng_sdrdevice_source_0, '0', qtgui_freq_sink_x_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
