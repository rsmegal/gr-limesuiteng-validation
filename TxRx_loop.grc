options:
  parameters:
    description: Test USB and XTRX devices in a Tx-Rx connection.
    generate_options: qt_gui
    id: TxRx_loop
    output_language: python
    title: USB and XTRX device TxRx loop
  states: {}

blocks:
- name: BBtype
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: Baseband signal type
    label0: constant
    label1: cosine
    label2: sawtooth
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: LPF
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: NGsink
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,1
    label: LimeNG sink
    label0: USB
    label1: XTRX
    label2: 'null'
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '2'
    widget: radio_buttons
  states: {}
- name: NGsource
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,1,1,1
    label: LimeNG source
    label0: USB
    label1: XTRX
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: RXcarrier_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: RX frequency [MHz]
    start: '100'
    step: '1'
    stop: '1000'
    value: '800.0'
  states: {}
- name: RXgainUSB
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: USB Rx Gain [dB]
    min_len: '70'
    rangeType: int
    start: '-12'
    step: '1'
    stop: '61'
    value: '20'
  states: {}
- name: RXgainXTRX
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: XTRX Rx Gain [dB]
    min_len: '70'
    rangeType: int
    start: '-12'
    step: '1'
    stop: '61'
    value: '20'
  states: {}
- name: TXcarrier_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: TX frequency [MHz]
    start: '100'
    step: '1'
    stop: '1000'
    value: '800.0'
    widget: eng
  states: {}
- name: TXgainUSB
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: USB TX Gain [dB]
    min_len: '70'
    rangeType: int
    start: '0'
    step: '1'
    stop: '52'
    value: '20'
  states: {}
- name: TXgainXTRX
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: XTRX TX Gain [dB]
    min_len: '70'
    rangeType: int
    start: '0'
    step: '1'
    stop: '52'
    value: '20'
  states: {}
- name: USB_sink_port
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,3,1,1
    label: USB sink port
    label0: Band1
    label1: Band2
    num_opts: '2'
    option0: Band1
    option1: Band2
    type: string
    value: Band1
    widget: radio_buttons
  states: {}
- name: XTRX_sink_port
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,2,1,1
    label: XTRX sink port
    label0: Band1
    label1: Band2
    num_opts: '2'
    option0: Band1
    option1: Band2
    type: string
    value: Band2
    widget: radio_buttons
  states: {}
- name: bb_offset
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,1
    label: bb offset
    type: real
    value: '0'
  states: {}
- name: bbamp
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: baseband amp.
    type: real
    value: '0.5'
  states: {}
- name: bbfreq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: baseband frequency [MHz]
    start: '0'
    step: '0.1'
    stop: samp_rate/1e6
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: bbamp
    freq: bbfreq*1e6
    offset: bb_offset+bb_offset*1j
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: bbamp
    freq: bbfreq*1e6
    offset: bb_offset+bb_offset*1j
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_1
  id: analog_sig_source_x
  parameters:
    amp: bbamp
    freq: bbfreq*1e6
    offset: bb_offset+bb_offset*1j
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: NGsource
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: NGsink
    type: complex
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: BBtype
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: limesuiteng_sdrdevice_sink_0_0
  id: limesuiteng_sdrdevice_sink
  parameters:
    antenna: USB_sink_port
    calibrate_dciq: Disabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: LimeSDR-USB
    gain_generic: TXgainUSB
    gfir_bandwidth: '0'
    lpf: 10e6
    nco_offset: '0'
    rf_freq: TXcarrier_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: limesuiteng_sdrdevice_sink_0_0_0
  id: limesuiteng_sdrdevice_sink
  parameters:
    antenna: XTRX_sink_port
    calibrate_dciq: Disabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: LimeSDR XTRX
    gain_generic: TXgainXTRX
    gfir_bandwidth: '0'
    lpf: 10e6
    nco_offset: '0'
    rf_freq: TXcarrier_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: '''LNAW'''
    calibrate_dciq: Disabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: LimeSDR XTRX
    gain_generic: RXgainXTRX
    gfir_bandwidth: '0'
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: LPF
    nco_offset: '0.0'
    override_lms7002m_rx_gains: Disabled
    rf_freq: RXcarrier_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: limesuiteng_sdrdevice_source_0_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: '''LNAW'''
    calibrate_dciq: Disabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: LimeSDR-USB
    gain_generic: RXgainUSB
    gfir_bandwidth: '0'
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: LPF
    nco_offset: '0.0'
    override_lms7002m_rx_gains: Disabled
    rf_freq: RXcarrier_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: TXcarrier_freq*1e6
    fftsize: '1024'
    gui_hint: 6,0,2,2
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: RXcarrier_freq*1e6
    fftsize: '1024'
    gui_hint: 6,2,2,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 4,0,2,2
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    gui_hint: 4,2,2,2
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0_1, '0', blocks_selector_0_1, '0']
- [analog_sig_source_x_0_1_0, '0', blocks_selector_0_1, '1']
- [analog_sig_source_x_0_1_1, '0', blocks_selector_0_1, '2']
- [blocks_selector_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_selector_0_0, '0', limesuiteng_sdrdevice_sink_0_0, '0']
- [blocks_selector_0_0, '1', limesuiteng_sdrdevice_sink_0_0_0, '0']
- [blocks_selector_0_0, '2', blocks_throttle2_0, '0']
- [blocks_selector_0_1, '0', blocks_selector_0_0, '0']
- [blocks_selector_0_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', blocks_selector_0, '1']
- [limesuiteng_sdrdevice_source_0_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
